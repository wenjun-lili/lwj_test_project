# Keil uVision project AutoGas.uvprojx, settings and files
target AutoGas (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AutoGas +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\globalVar;..\..\User\key;..\..\User\pump;..\..\User\sensorCO2;..\..\User\sensorFlow;..\..\User\sensorPe;..\..\User\sensorPressure;..\..\User\bsp;..\..\User\utility;..\..\User\I2C;..\..\User\beep;..\..\User\evalve;..\..\User\exti;..\..\User\SysTick;..\..\User\Led;..\..\User\collectionProcess
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h NVIC_Config.c
    ../../User/usart/: bsp_usart.c
    ../../User/globalVar/: globalVar.c
    ../../User/pump/: pump.c
    ../../User/sensorCO2/: sensorCO2.c
    ../../User/sensorFlow/: sensorFlow.c
    ../../User/sensorPe/: sensorPe.c
    ../../User/bsp/: bsp.c
    ../../User/utility/: utility.c
    ../../User/beep/: beep.c
    ../../User/evalve/: evalve.c
    ../../User/exti/: bsp_exti.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/I2C/: bsp_i2c_ee.c
    ../../User/Led/: bsp_led.c
    ../../User/collectionProcess/: collectionProcess.c
  group README
    ../../Readme/: RevisionLog.txt
