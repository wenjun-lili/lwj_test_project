# Keil uVision project RBCS_Seekya.uvprojx, settings and files
target RBCS_Seekya (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RBCS_Seekya +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\StartUp\arm;..\stdPeriph_Driver\src;..\stdPeriph_Driver\inc;..\User;..\User\sdio;..\fatfs;..\fatfs\option;..\User\key;..\User\evalve;..\App;..\User\bme280;..\User\faultHandle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c stm32f10x_it.c utility.c ADS7816.c steppermotor.c beep.c led.c Timer.c NVIC_Config.c bsp.c bsp_i2c_eeprom.c bsp_i2c_gpio.c systick.c globalval.c sd_fat_app.c Dwin.c adc.c sys.c
    ../User/sdio/: bsp_sdio_sdcard.c sdio_test.c
    ../User/usart/: bsp_usart.c
    ../User/key/: bsp_button.c process.c
    ../User/evalve/: evalve.c
    ../User/bme280/: BME280.c myiic.c
    ../User/faultHandle/: faultHandle.c
  group Startup
    ../StartUp/arm/: startup_stm32f10x_hd.s
  group FWlib
    ../stdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../DOC/: readme.txt
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FATFS
    ../fatfs/: diskio.c ff.c
    ../fatfs/option/: cc936.c
  group App
    ../App/: Measurement.c date.c rtc.c framedisplay.c RBC_PC_CmdRule.c GasRoad.c num2str.c
